options:
  parameters:
    author: Adrian YO8RZZ
    description: CE-SSB example with re-scaling to normalized output in (-1.0, 1.0) as expected by most DACs
    generate_options: qt_gui
    id: ce_ssb_example_levels
    output_language: python
    title: CE-SSB example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: Audio scale (0.2 is clipping limit)
    start: '0.05'
    step: '0.05'
    stop: '2.0'
    value: '0.2'
    widget: slider
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '800'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '1200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_range_0
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ssbaudioprocessed.wav
    repeat: 'True'
  states: {state: disabled}
- name: cessb_clipper_cc_0
  id: cessb_clipper_cc
  parameters:
    clip: '0.2'
  states: {}
- name: cessb_stretcher_cc_0
  id: cessb_stretcher_cc
  parameters: {}
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.complex_band_pass_2(1, samp_rate, 200, 2700, 200, 90, window.WIN_BLACKMAN_HARRIS)
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.complex_band_pass_2(1, samp_rate, 200, 2700, 200, 90, window.WIN_BLACKMAN_HARRIS)
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.complex_band_pass_2(1, samp_rate, 200, 2700, 200, 90, window.WIN_BLACKMAN_HARRIS)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.fft import window
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '128'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '128'
    srate: samp_rate
    type: complex
    update_time: '0.02'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', fft_filter_xxx_0, '0']
- [blocks_throttle_0, '0', blocks_float_to_complex_1, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [cessb_clipper_cc_0, '0', fft_filter_xxx_0_0, '0']
- [cessb_stretcher_cc_0, '0', fft_filter_xxx_0_0_0, '0']
- [fft_filter_xxx_0, '0', cessb_clipper_cc_0, '0']
- [fft_filter_xxx_0_0, '0', cessb_stretcher_cc_0, '0']
- [fft_filter_xxx_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
